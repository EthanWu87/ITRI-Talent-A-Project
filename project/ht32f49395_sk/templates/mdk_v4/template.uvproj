# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: HT32F49395_100LQFP Holtek
  output: Template +hex
  c flags: Optim=1
  c define: USE_HT32F49395_100LQFP,USE_STDPERIPH_DRIVER,USE_HT32F49395_SK
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\ht32f493x5_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: ht32f493x5_int.c ht32f493x5_clock.c main.c
  group bsp
    ../../../ht32f493x5_board/: ht32f493x5_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_ht32f493x5.s
    ../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
  group firmware
    ../../../../libraries/drivers/src/: ht32f493x5_acc.c ht32f493x5_adc.c ht32f493x5_bpr.c ht32f493x5_can.c ht32f493x5_crc.c ht32f493x5_crm.c ht32f493x5_dac.c ht32f493x5_debug.c ht32f493x5_dma.c ht32f493x5_exint.c ht32f493x5_flash.c ht32f493x5_gpio.c ht32f493x5_i2c.c ht32f493x5_misc.c ht32f493x5_pwc.c ht32f493x5_rtc.c ht32f493x5_sdio.c ht32f493x5_spi.c ht32f493x5_tmr.c ht32f493x5_usart.c ht32f493x5_usb.c ht32f493x5_wdt.c ht32f493x5_wwdt.c ht32f493x5_xmc.c
  group readme
    ../: readme.txt
