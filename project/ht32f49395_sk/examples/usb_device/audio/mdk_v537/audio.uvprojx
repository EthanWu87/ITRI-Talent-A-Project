# Keil uVision project audio.uvprojx, settings and files
target audio (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: audio +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HT32F49395_100LQFP,USE_STDPERIPH_DRIVER,USE_HT32F49395_SK
  c include: ..\inc;..\..\..\..\..\ht32f493x5_board;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\middlewares\usbd_drivers\inc;..\..\..\..\..\..\middlewares\usbd_class\audio;..\..\..\..\..\..\middlewares\i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c main.c audio_codec.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
  group bsp
    ../../../../../ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: ht32f493x5_acc.c ht32f493x5_adc.c ht32f493x5_bpr.c ht32f493x5_can.c ht32f493x5_crc.c ht32f493x5_crm.c ht32f493x5_dac.c ht32f493x5_debug.c ht32f493x5_dma.c ht32f493x5_exint.c ht32f493x5_flash.c ht32f493x5_gpio.c ht32f493x5_i2c.c ht32f493x5_misc.c ht32f493x5_pwc.c ht32f493x5_rtc.c ht32f493x5_sdio.c ht32f493x5_spi.c ht32f493x5_tmr.c ht32f493x5_usart.c ht32f493x5_usb.c ht32f493x5_wdt.c ht32f493x5_wwdt.c ht32f493x5_xmc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_ht32f493x5.s
  group usbd_drivers
    ../../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../../middlewares/usbd_class/audio/: audio_class.c audio_desc.c
  group readme
    ../: readme.txt
