# Keil uVision project sdio_fatfs.uvprojx, settings and files
target sdio_fatfs (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sdio_fatfs +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32F49395_100LQFP,USE_STDPERIPH_DRIVER,USE_HT32F49395_SK
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\ht32f493x5_board;..\..\..\..\..\..\middlewares\3rd_party\fatfs\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c ht32_sdio.c main.c diskio.c
  group bsp
    ../../../../../ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: ht32f493x5_gpio.c ht32f493x5_misc.c ht32f493x5_sdio.c ht32f493x5_dma.c ht32f493x5_crm.c ht32f493x5_usart.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_ht32f493x5.s
  group fatfs
    ../../../../../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group readme
    ../: readme.txt
