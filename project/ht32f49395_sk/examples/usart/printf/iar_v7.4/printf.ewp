# IAR project printf.ewp, settings and files
configuration printf (ARM)
  General.OGChipSelectEditMenu: HT32F49395_100LQFP Holtek HT32F49395_100LQFP
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HT32F49395_100LQFP; USE_STDPERIPH_DRIVER; USE_HT32F49395_SK
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\ht32f493x5_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: printf.srec
  ILINK.IlinkOutputFile: printf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../ht32f493x5_board/: ht32f493x5_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_ht32f493x5.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
  group firmware
    ../../../../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_gpio.c ht32f493x5_misc.c ht32f493x5_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: ht32f493x5_int.c ht32f493x5_clock.c main.c
