# Keil uVision project gen_ramdom_number.uvprojx, settings and files
target ht32f49395_sk (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ht32f493x5_gen_random_number +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32F49395_100LQFP,USE_STDPERIPH_DRIVER,USE_HT32F49395_SK
  c include: ..\inc;..\..\..\project\ht32f493x5_board;..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c random.c main.c
  group bsp
    ../../../project/ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_rtc.c ht32f493x5_usart.c ht32f493x5_gpio.c ht32f493x5_misc.c ht32f493x5_bpr.c ht32f493x5_pwc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_ht32f493x5.s
    ../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
  group readme
    ../: readme.txt
