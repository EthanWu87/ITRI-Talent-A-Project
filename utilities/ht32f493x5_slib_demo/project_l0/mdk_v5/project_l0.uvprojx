# Keil uVision project project_l0.uvprojx, settings and files
target ht32f49395_sk (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ht32f493x5_project_l0 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32F49395_100LQFP,USE_STDPERIPH_DRIVER,USE_HT32F49395_SK,ARM_MATH_CM4
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\project\ht32f493x5_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\slib-w-xo.sct
  link misc: --symdefs=fir_filter_symbol.txt
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c arm_fir_data.c math_helper.c main.c
  group bsp
    ../../../../project/ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_usart.c ht32f493x5_flash.c ht32f493x5_gpio.c ht32f493x5_misc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_ht32f493x5.s
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group readme
    ../: readme.txt
