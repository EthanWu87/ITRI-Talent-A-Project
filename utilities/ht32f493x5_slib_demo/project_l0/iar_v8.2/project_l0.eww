<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_l0.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>project_l0</project>
                <configuration>ht32f49395_sk</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
