<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gen_ramdom_number.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>gen_ramdom_number</project>
                <configuration>ht32f49395_sk</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
