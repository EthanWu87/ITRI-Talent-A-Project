# IAR project project_l0.ewp, settings and files
configuration ht32f49395_sk (ARM)
  General.OGChipSelectEditMenu: HT32F49395_100LQFP Holtek HT32F49395_100LQFP
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HT32F49395_100LQFP; USE_STDPERIPH_DRIVER; USE_HT32F49395_SK; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\ht32f493x5_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ht32f493x5_project_l0.hex
  postbuild: "$TOOLKIT_DIR$\bin\isymexport.exe" --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: HT32F49395_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/ht32f493x5_board/: ht32f493x5_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_ht32f493x5.s
    ../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_usart.c ht32f493x5_flash.c ht32f493x5_gpio.c ht32f493x5_misc.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c ht32f493x5_clock.c ht32f493x5_int.c main.c math_helper.c
